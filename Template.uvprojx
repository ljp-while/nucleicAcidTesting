# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\APP\exti;.\APP\time;.\APP\dma;.\APP\rtc;.\APP\iic;.\APP\hwjs;.\APP\flash;.\APP\spi;.\Picture;.\APP\dcmi;.\APP\ov5640;.\APP\imageProcess;.\APP\flash;.\APP\spi;.\APP\powerKey;.\APP\time4;.\APP\time5;.\APP\rtc;.\APP\st7567;.\Public
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rng.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_dcmi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group APP
    ./APP/led/: led.c
    ./APP/dcmi/: dcmi.c
    ./APP/ov5640/: ov5640.c sccb.c
    ./APP/imageProcess/: imageProcess.c
    ./APP/spi/: spi.c
    ./APP/powerKey/: powerKey.c
    ./APP/time4/: time4.c
    ./APP/time5/: time5.c
    ./APP/rtc/: rtc.c
    ./APP/flash/: flash.c
    ./APP/time/: time.c
    ./APP/st7567/: st7567.c
